options:
  parameters:
    category: Custom
    description: Channel-estimator diagnostics from the AIE PHY CSI and frame tags.
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: AIE Channel Estimator Diagnostics
  states: {}

blocks:
- name: diagnostic_label_init
  id: snippet
  parameters:
    code: self.set_diagnostic_estimator(self.diagnostic_estimator)
    section: main_after_init
  states: {}
- name: diagnostic_estimator
  id: variable
  parameters:
    comment: Loaded from kernel/build/frame_equalizer_build_mode.txt before block construction.
    value: None
  states: {}
- name: diagnostic_max_records
  id: variable
  parameters:
    comment: Maximum number of frame and CRC event records written to JSONL.
    value: '10000'
  states: {}
- name: diagnostic_output
  id: variable
  parameters:
    comment: Bounded channel-estimator diagnostic export.
    value: '"data/tmp_out/channel_estimator_diagnostic.jsonl"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"data/raw_capture/206.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/tmp_out/replaced.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_channel_estimator_diagnostic
  id: epy_block
  parameters:
    _source_code: |
      # This block observes frame tags from the AIE receiver and produces
      # bounded diagnostic records and display vectors without altering decoded bytes.
      #
      # Input stream:
      #   The AIE hard-decision byte stream, used only to locate absolute tag offsets.
      #
      # Message input:
      #   The MAC decoder emits one message after a CRC-valid packet. Its diag port sends one metadata
      #   dictionary containing coded-bit vectors and optional IQ vectors for BER/EVM.
      #
      # Stream outputs:
      #   CSI magnitude, CSI phase residual, delay profile, and eight scalar metrics.
      #
      # The analyzer deliberately does not forward its input. A separate branch keeps
      # the production byte stream connected directly to the MAC decoder.
      #
      # JSONL events:
      #   frame       One valid CSI tag with raw CSI and derived metrics.
      #   crc_ok      One payload passed the MAC decoder CRC check.
      #   invalid_csi A tag was malformed or contained no usable channel power.
      #   pre_fec_coded_ber Counts mismatches between received coded bits and the
      #                     decoder-corrected re-encoded bits on CRC-valid frames.
      #
      # Coded BER uses the bit region published by decode_mac_BER, which omits the
      # final OFDM symbol; failed-CRC frames do not provide a comparison reference.
      #
      # Metric meanings:
      #   Flatness and deepest fade describe frequency selectivity.
      #   Noise enhancement estimates sensitivity of a reciprocal equalizer.
      #   Phase residual removes linear timing slope and exposes ripple.
      #   Delay spread is an approximate 64-point impulse-response measurement.

      import json
      import os
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class channel_estimator_diagnostic(gr.basic_block):
          """Analyze frame-level CSI tags and generate quality metrics.

              Args:
                  output_path: JSONL destination. An empty string disables file output.
                  max_records: Maximum number of JSONL records retained.
                  report_interval: Number of frames between console summaries.
                  headless_idle_seconds: Inactivity timeout for unattended finite-file runs.
                  estimator_label: Human-readable label identifying the XCLBIN estimator.
                  sample_rate: Input sample rate in samples per second.

              The input is intentionally not forwarded. The production receiver branch
              remains connected directly to the MAC decoder.
              """

          def __init__(self, output_path="data/tmp_out/channel_estimator_diagnostic.jsonl",
                       max_records=10000, report_interval=25,
                       headless_idle_seconds=10.0, estimator_label="CNN", sample_rate=20e6):
              # The first three outputs are vectors; the remaining eight outputs are
              # scalar metrics repeated once per analyzed frame for the GUI sinks.
              gr.basic_block.__init__(
                  self,
                  name="channel_estimator_diagnostic",
                  in_sig=[np.int8],
                  out_sig=[
                      (np.float32, 53), (np.float32, 53), (np.float32, 64),
                      np.float32, np.float32, np.float32, np.float32,
                      np.float32, np.float32, np.float32, np.float32,
                  ],
              )
              # Queue completed frame analyses until all output ports can accept one item.
              self.output_path = output_path
              self.sample_rate = float(sample_rate)
              if self.sample_rate <= 0.0:
                  raise ValueError("sample_rate must be positive")
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.pending = []
              self.previous_csi = None
              self.frame_count = 0
              self.crc_valid_count = 0
              self.record_count = 0
              self.pre_fec_bit_errors = 0
              self.pre_fec_bits_compared = 0
              self.pre_fec_ber_samples = 0
              self.evm_samples = 0
              self.evm_error_power = 0.0
              self.evm_reference_power = 0.0
              self.evm_aligned_percent_sum = 0.0
              self.evm_lock = threading.Lock()
              self.lock = threading.Lock()
              self.last_work = time.monotonic()
              self.seen_input = False
              self.stopping = False
              self.message_port_register_in(pmt.intern("crc_ok"))
              self.set_msg_handler(pmt.intern("crc_ok"), self._handle_crc_ok)
              self.message_port_register_in(pmt.intern("diag"))
              self.set_msg_handler(pmt.intern("diag"), self._handle_diag)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              self.output_file = open(output_path, "w", encoding="ascii") if output_path else None

              # In unattended runs the watchdog quits Qt after finite input stops.
              if os.environ.get("WIFI_DIAGNOSTIC_HEADLESS") == "1":
                  self.headless_thread = threading.Thread(
                      target=self._headless_watchdog,
                      args=(max(1.0, float(headless_idle_seconds)),),
                      daemon=True,
                  )
                  self.headless_thread.start()

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          @staticmethod
          def _finite(value):
              return float(value) if np.isfinite(value) else None

          def _write_record(self, record):
              with self.lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(json.dumps(record, separators=(",", ":"), allow_nan=False) + "\n")
                  self.output_file.flush()
                  self.record_count += 1

          def _handle_crc_ok(self, _message):
              with self.lock:
                  self.crc_valid_count += 1
                  crc_valid_count = self.crc_valid_count
              self._write_record({
                  "event": "crc_ok",
                  "crc_valid_count": crc_valid_count,
                  "estimator": self.estimator_label,
              })

          def _headless_watchdog(self, idle_seconds):
              while not self.stopping:
                  time.sleep(0.25)
                  if self.seen_input and time.monotonic() - self.last_work >= idle_seconds:
                      try:
                          from PyQt5 import QtWidgets
                          app = QtWidgets.QApplication.instance()
                          if app is not None:
                              app.quit()
                      except ImportError:
                          pass
                      return

          def _decode_tags(self, tags):
              grouped = {}
              for tag in tags:
                  key = pmt.symbol_to_string(tag.key)
                  grouped.setdefault(int(tag.offset), {})[key] = tag.value
              return grouped

          def _analyze(self, offset, values):
              # The AIE adapter publishes CSI as 52 occupied carriers: -26..-1 and
              # +1..+26. A missing CSI tag means this offset is not a frame record.
              if "csi" not in values:
                  return
              csi = np.asarray(pmt.c32vector_elements(values["csi"]), dtype=np.complex64)
              if csi.size != 52 or not np.all(np.isfinite(csi)):
                  self._write_record({
                      "event": "invalid_csi",
                      "offset": offset,
                      "size": int(csi.size),
                      "estimator": self.estimator_label,
                  })
                  return

              power = np.abs(csi).astype(np.float64) ** 2
              mean_power = float(np.mean(power))
              if mean_power <= np.finfo(np.float64).tiny:
                  self._write_record({
                      "event": "invalid_csi",
                      "offset": offset,
                      "reason": "zero_power",
                      "estimator": self.estimator_label,
                  })
                  return

              floor = max(mean_power * 1e-12, np.finfo(np.float64).tiny)
              # Use a relative floor so logarithms remain finite for deep fades.
              median_power = max(float(np.median(power)), floor)
              magnitude_db = 10.0 * np.log10(np.maximum(power, floor) / median_power)
              subcarriers = np.concatenate((np.arange(-26, 0), np.arange(1, 27)))
              # Remove the best-fit linear phase slope before displaying phase ripple.
              unwrapped_phase = np.unwrap(np.angle(csi).astype(np.float64))
              phase_fit = np.polyfit(subcarriers, unwrapped_phase, 1)
              phase_residual = unwrapped_phase - np.polyval(phase_fit, subcarriers)

              shifted_channel = np.zeros(64, dtype=np.complex128)
              # Reinsert the occupied carriers into shifted 64-point FFT-bin order.
              # DC and guard bins remain zero because they are not channel estimates.
              shifted_channel[6:32] = csi[:26]
              shifted_channel[33:59] = csi[26:]
              impulse = np.fft.ifft(np.fft.ifftshift(shifted_channel))
              delay_power = np.abs(impulse) ** 2
              # The 20 MHz sample period is derived from the configured sample rate; report RMS delay in nanoseconds.
              delay_power /= max(float(np.max(delay_power)), floor)
              delay_profile_db = 10.0 * np.log10(np.maximum(delay_power, 1e-8))
              peak = int(np.argmax(delay_power))
              distances = (np.arange(64) - peak + 32) % 64 - 32
              delay_weight = delay_power / np.sum(delay_power)
              mean_delay = float(np.sum(distances * delay_weight))
              rms_delay_ns = (1e9 / self.sample_rate) * np.sqrt(
                  np.sum(((distances - mean_delay) ** 2) * delay_weight)
              )

              spectral_flatness_db = 10.0 * np.log10(
                  np.exp(np.mean(np.log(np.maximum(power, floor)))) / mean_power
              )
              noise_enhancement_db = 10.0 * np.log10(
                  mean_power * np.mean(1.0 / np.maximum(power, floor))
              )
              deepest_fade_db = 10.0 * np.log10(max(float(np.min(power)), floor) / median_power)
              if self.previous_csi is None:
                  stability = 0.0
              else:
                  # Correlation is insensitive to overall gain and is useful for spotting
                  # packet-to-packet channel changes or unstable estimates.
                  denominator = np.linalg.norm(self.previous_csi) * np.linalg.norm(csi)
                  stability = float(abs(np.vdot(self.previous_csi, csi)) / denominator) if denominator else 0.0
              self.previous_csi = csi.copy()

              self.frame_count += 1
              snr_db = pmt.to_double(values["snr"]) if "snr" in values else np.nan
              frequency_offset_hz = (
                  pmt.to_double(values["frequency offset"])
                  if "frequency offset" in values else np.nan
              )
              beta_rad = pmt.to_double(values["beta"]) if "beta" in values else np.nan
              frame_bytes = pmt.to_uint64(values["frame bytes"]) if "frame bytes" in values else 0
              encoding = pmt.to_uint64(values["encoding"]) if "encoding" in values else 0
              with self.lock:
                  crc_valid_count = self.crc_valid_count

              metrics = {
                  "snr_db": self._finite(snr_db),
                  "frequency_offset_hz": self._finite(frequency_offset_hz),
                  "beta_rad": self._finite(beta_rad),
                  "deepest_fade_db": self._finite(deepest_fade_db),
                  "spectral_flatness_db": self._finite(spectral_flatness_db),
                  "noise_enhancement_db": self._finite(noise_enhancement_db),
                  "phase_slope_rad_per_subcarrier": self._finite(phase_fit[0]),
                  "phase_residual_rms_rad": self._finite(np.sqrt(np.mean(phase_residual ** 2))),
                  "peak_delay_sample": peak,
                  "rms_delay_spread_ns": self._finite(rms_delay_ns),
                  "previous_csi_correlation": self._finite(stability),
              }
              self._write_record({
                  "event": "frame",
                  "frame_index": self.frame_count,
                  "offset": offset,
                  "estimator": self.estimator_label,
                  "frame_bytes": int(frame_bytes),
                  "encoding": int(encoding),
                  "crc_valid_count": crc_valid_count,
                  "metrics": metrics,
                  "csi_real": csi.real.astype(float).tolist(),
                  "csi_imag": csi.imag.astype(float).tolist(),
              })
              self.pending.append((
                  np.insert(magnitude_db, 26, -50.0).astype(np.float32),
                  np.insert(phase_residual, 26, 0.0).astype(np.float32),
                  delay_profile_db.astype(np.float32),
                  np.asarray((
                      snr_db, frequency_offset_hz, deepest_fade_db,
                      spectral_flatness_db, noise_enhancement_db,
                      rms_delay_ns, stability,
                      crc_valid_count / self.frame_count,
                  ), dtype=np.float32),
              ))

              if self.frame_count % self.report_interval == 0:
                  ratio = crc_valid_count / self.frame_count
                  print(
                      "channel diagnostic: frames={} crc_ok={} ratio={:.3f} "
                      "snr_db={:.2f} fade_db={:.2f} stability={:.4f} delay_ns={:.1f}".format(
                          self.frame_count, crc_valid_count, ratio, snr_db,
                          deepest_fade_db, stability, rms_delay_ns
                      )
                  )

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              if len(in0):
                  self.seen_input = True
                  self.last_work = time.monotonic()
                  start = self.nitems_read(0)
                  tags = self.get_tags_in_range(0, start, start + len(in0))
                  for offset, values in sorted(self._decode_tags(tags).items()):
                      self._analyze(offset, values)
                  self.consume(0, len(in0))

              produced = min(min(map(len, output_items)), len(self.pending))
              for index in range(produced):
                  magnitude_db, phase_residual, delay_profile_db, metrics = self.pending.pop(0)
                  output_items[0][index] = magnitude_db
                  output_items[1][index] = phase_residual
                  output_items[2][index] = delay_profile_db
                  for metric_index in range(8):
                      output_items[3 + metric_index][index] = metrics[metric_index]
              return produced

          def stop(self):
              self.stopping = True
              with self.lock:
                  if self.output_file is not None:
                      self.output_file.close()
                      self.output_file = None
              return True

          def _metadata_uint64(self, metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _record_coded_ber(self, metadata, rx_bits, reference_bits):
              frame_bytes = self._metadata_uint64(metadata, 'frame bytes')
              encoding = self._metadata_uint64(metadata, 'encoding')
              if rx_bits.size == 0 or rx_bits.size != reference_bits.size:
                  self._write_record({
                      'event': 'invalid_coded_ber_pair',
                      'received_bits': int(rx_bits.size),
                      'reference_bits': int(reference_bits.size),
                      'frame_bytes': frame_bytes,
                      'encoding': encoding,
                      'estimator': self.estimator_label,
                  })
                  return
              if np.any(rx_bits > 1) or np.any(reference_bits > 1):
                  self._write_record({
                      'event': 'invalid_coded_ber_pair',
                      'reason': 'values_are_not_bits',
                      'estimator': self.estimator_label,
                  })
                  return

              bit_errors = int(np.count_nonzero(rx_bits != reference_bits))
              bits_compared = int(rx_bits.size)
              sample_ber = bit_errors / bits_compared
              self.pre_fec_ber_samples += 1
              self.pre_fec_bit_errors += bit_errors
              self.pre_fec_bits_compared += bits_compared
              cumulative_ber = self.pre_fec_bit_errors / self.pre_fec_bits_compared
              self._write_record({
                  'event': 'pre_fec_coded_ber',
                  'sample_index': self.pre_fec_ber_samples,
                  'frame_bytes': frame_bytes,
                  'encoding': encoding,
                  'bit_errors': bit_errors,
                  'bits_compared': bits_compared,
                  'ber': sample_ber,
                  'cumulative_bit_errors': self.pre_fec_bit_errors,
                  'cumulative_bits_compared': self.pre_fec_bits_compared,
                  'cumulative_ber': cumulative_ber,
                  'region': 'deinterleaved coded bits, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              print(
                  'pre-FEC coded BER sample {}: {}/{} ({:.6g}); cumulative {:.6g}'.format(
                      self.pre_fec_ber_samples, bit_errors, bits_compared,
                      sample_ber, cumulative_ber
                  )
              )

          def _handle_diag(self, message):
              # The decoder combines coded-bit and IQ diagnostics in one PDU dictionary.
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  self._write_record({
                      'event': 'invalid_coded_ber_message',
                      'estimator': self.estimator_label,
                  })
                  return
              metadata = pmt.car(message)
              diagnostic = pmt.cdr(message)
              received = pmt.dict_ref(diagnostic, pmt.intern('pre_viterbi'), pmt.PMT_NIL)
              corrected = pmt.dict_ref(diagnostic, pmt.intern('corrected_coded'), pmt.PMT_NIL)
              if not pmt.is_u8vector(received) or not pmt.is_u8vector(corrected):
                  self._write_record({
                      'event': 'invalid_coded_ber_message',
                      'reason': 'coded_bit_vectors_missing',
                      'estimator': self.estimator_label,
                  })
                  return
              received = np.asarray(pmt.u8vector_elements(received), dtype=np.uint8)
              corrected = np.asarray(pmt.u8vector_elements(corrected), dtype=np.uint8)
              self._record_coded_ber(metadata, received, corrected)
    estimator_label: diagnostic_estimator
    headless_idle_seconds: '10.0'
    max_records: diagnostic_max_records
    output_path: diagnostic_output
    report_interval: '25'
    sample_rate: samp_rate
  states: {}
- name: evm_build_mode_check
  id: snippet
  parameters:
    code: |-
      from pathlib import Path

      build = Path('kernel/build')
      marker = build / 'frame_equalizer_build_mode.txt'
      artifacts = [build / 'final.xclbin', build / 'insts.bin']
      missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
      if missing: raise RuntimeError('EVM diagnostics require kernel build output(s): ' + ', '.join(missing) + '; run `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=0 compile` from stage42/')
      mode = dict((parts[0].strip(), parts[1].strip()) for parts in (line.split('=', 1) for line in marker.read_text(encoding='ascii').splitlines()) if len(parts) == 2)
      if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '0': raise RuntimeError('EVM diagnostics require DFRAME_EQUALIZER_OUTPUT_SYMBOLS=0; rebuild with `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=0 compile`')
      if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts): raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild the kernel')
      if not mode.get('EQUALIZER_ALGORITHM'): raise RuntimeError(str(marker) + ' is missing EQUALIZER_ALGORITHM; rebuild the kernel')
      self.diagnostic_estimator = mode['EQUALIZER_ALGORITHM']
    section: init_before_blocks
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: qtgui_number_sink_channel_metrics
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.0'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    color5: ("blue", "red")
    color6: ("blue", "red")
    color7: ("blue", "red")
    color8: ("blue", "red")
    factor8: '100'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,2
    label1: '"SNR"'
    label2: '"CFO"'
    label3: '"Deepest fade"'
    label4: '"Spectral flatness"'
    label5: '"Noise enhancement"'
    label6: '"RMS delay spread"'
    label7: '"CSI correlation"'
    label8: '"CRC success"'
    max: '100'
    min: '-100'
    name: '"Channel Metrics"'
    nconnections: '8'
    type: float
    unit1: '"dB"'
    unit2: '"Hz"'
    unit3: '"dB"'
    unit4: '"dB"'
    unit5: '"dB"'
    unit6: '"ns"'
    unit7: '""'
    unit8: '"%"'
  states: {}
- name: qtgui_vector_sink_csi_magnitude
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: '"Relative CSI magnitude"'
    legend: 'False'
    name: '"CSI Magnitude"'
    vlen: '53'
    width1: '2'
    x_axis_label: '"Occupied subcarrier index"'
    x_start: '-26'
    x_step: '1'
    y_axis_label: '"Relative gain (dB)"'
    y_units: '"dB"'
    ymax: '20'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_csi_phase
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"red"'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: '"Detrended CSI phase"'
    legend: 'False'
    name: '"CSI Phase Residual"'
    vlen: '53'
    width1: '2'
    x_axis_label: '"Occupied subcarrier index"'
    x_start: '-26'
    x_step: '1'
    y_axis_label: '"Residual phase (rad)"'
    y_units: '"rad"'
    ymax: '3.2'
    ymin: '-3.2'
  states: {}
- name: qtgui_vector_sink_delay_profile
  id: qtgui_vector_sink_f
  parameters:
    color1: '"dark green"'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: '"Normalized delay power"'
    legend: 'False'
    name: '"Estimated Power Delay Profile"'
    vlen: '64'
    width1: '2'
    x_axis_label: '"Delay"'
    x_start: '0'
    x_step: '0.05'
    x_units: '"us"'
    y_axis_label: '"Normalized power (dB)"'
    y_units: '"dB"'
    ymax: '3'
    ymin: '-80'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: diag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: diag
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [epy_channel_estimator_diagnostic, '0', qtgui_vector_sink_csi_magnitude, '0']
- [epy_channel_estimator_diagnostic, '1', qtgui_vector_sink_csi_phase, '0']
- [epy_channel_estimator_diagnostic, '10', qtgui_number_sink_channel_metrics, '7']
- [epy_channel_estimator_diagnostic, '2', qtgui_vector_sink_delay_profile, '0']
- [epy_channel_estimator_diagnostic, '3', qtgui_number_sink_channel_metrics, '0']
- [epy_channel_estimator_diagnostic, '4', qtgui_number_sink_channel_metrics, '1']
- [epy_channel_estimator_diagnostic, '5', qtgui_number_sink_channel_metrics, '2']
- [epy_channel_estimator_diagnostic, '6', qtgui_number_sink_channel_metrics, '3']
- [epy_channel_estimator_diagnostic, '7', qtgui_number_sink_channel_metrics, '4']
- [epy_channel_estimator_diagnostic, '8', qtgui_number_sink_channel_metrics, '5']
- [epy_channel_estimator_diagnostic, '9', qtgui_number_sink_channel_metrics, '6']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, virtual_sink_1_0_0, '0']
- [ieee802_11_decode_mac_EVM_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_EVM_0, out, virtual_sink_1_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', virtual_sink_1, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_1, '0', epy_channel_estimator_diagnostic, '0']
- [virtual_source_1_0, '0', epy_channel_estimator_diagnostic, crc_ok]
- [virtual_source_1_0_0, '0', epy_channel_estimator_diagnostic, diag]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
