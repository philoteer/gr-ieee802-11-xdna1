options:
  parameters:
    description: Preserve prepared samples and attach 2168-word estimated metadata.
    generate_options: no_gui
    id: channel_est_dump
    output_language: python
    run_options: run
    title: Channel Estimation Dump
  states: {}

blocks:
- name: dump_file
  id: variable
  parameters:
    value: dump_path or script_dir + "/tmp_data/preproc.iqdata"
  states: {}
- name: estimated_file
  id: variable
  parameters:
    value: output_path or script_dir + "/tmp_data/estimated.iqdata"
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: cnn is CNN-only; mlp enables the CNN estimator and MLP payload updater.
    value: script_dir + "/channel_est/build/" + estimator
  states: {}
- name: script_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(globals().get('__file__', 'AI-model-CNN-Channel-est/test/frame_equalizer_preproc/channel_est_dump.py')).resolve().parent)
  states: {}
- name: channel_estimate
  id: mlir_aie_mlir_aie_cpp_tagged_int64_to_int64
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    channel_estimate: 'True'
    kernel_name: MLIR_AIE
    nominal_frequency: 2.417e9
    num_slots: '1'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
    preprocess: 'False'
  states: {}
- name: dump_path
  id: parameter
  parameters:
    label: Prepared input
    type: str
    value: ''
  states: {}
- name: estimator
  id: parameter
  parameters:
    label: Estimator (cnn or mlp)
    type: str
    value: cnn
  states: {}
- name: output_path
  id: parameter
  parameters:
    label: Estimated output
    type: str
    value: ''
  states: {}
- name: sink
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: estimated_file
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: 20e6
    type: complex
  states: {}
- name: source
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: dump_file
    hdr_file: dump_file + ".hdr"
    repeat: 'False'
    type: complex
  states: {}
- name: to_complex
  id: mlir_aie_cint32_to_complex64
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
  states: {}
- name: to_fixed
  id: mlir_aie_complex64_to_cint32
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
    safe: 'False'
  states: {}

connections:
- [channel_estimate, '0', to_complex, '0']
- [source, '0', to_fixed, '0']
- [to_complex, '0', sink, '0']
- [to_fixed, '0', channel_estimate, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
