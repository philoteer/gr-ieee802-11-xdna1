options:
  parameters:
    description: Per-frame SNR, pre-FEC coded BER and equalized-payload EVM on CRC-valid frames, excluding the final OFDM symbol.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: NPU SNR BER and EVM CSV
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    value: '"data/raw_capture/"'
  states: {}
- name: dataset
  id: variable
  parameters:
    value: '"stress_test"'
  states: {state: disabled}
- name: dataset
  id: variable
  parameters:
    value: '"206"'
  states: {}
- name: dataset
  id: variable
  parameters:
    value: '"room_20260927"'
  states: {state: disabled}
- name: dataset
  id: variable
  parameters:
    value: '"stress_test_awgn_15db"'
  states: {state: disabled}
- name: diagnostic_output
  id: variable
  parameters:
    value: '"data/tmp_out/ " + dataset + ".csv"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/" + dataset  + ".sigmf"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.412e9
  states: {}
- name: kernel_build_dir
  id: variable
  parameters:
    comment: MLP_EVM_BY_CHANNEL
    value: '"/home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/xclbin_default/MLP_EVM_BY_CHANNEL"'
  states: {}
- name: kernel_build_dir
  id: variable
  parameters:
    comment: CNN_EVM_BY_CHANNEL/
    value: '"/home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/xclbin_default/CNN_EVM_BY_CHANNEL/"'
  states: {state: disabled}
- name: kernel_build_dir
  id: variable
  parameters:
    comment: LS
    value: '"/home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/xclbin_default/LS_EVM/"'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_snr_csv
  id: epy_block
  parameters:
    _source_code: |
      import csv
      import threading
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr


      class snr_csv(gr.basic_block):
          """One unbinned row per CRC-valid diagnostic PDU; no cross-frame joins."""

          def __init__(self, output_path='data/tmp_out/snr_ber.csv',
                       build_dir='kernel/build', output_symbols=False):
              gr.basic_block.__init__(self, name='SNR BER EVM CSV', in_sig=None, out_sig=None)
              self.output_path = output_path
              self.build_dir = build_dir
              self.output_symbols = bool(output_symbols)
              self.output_file = None
              self.writer = None
              self.frame_index = 0
              self.lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_diag)

          def start(self): 
              print("_")
              build = Path(self.build_dir)
              marker = build / 'frame_equalizer_build_mode.txt'
              artifacts = [build / 'final.xclbin', build / 'insts.bin']
              for path in [marker, *artifacts]:
                  if not path.is_file():
                      raise RuntimeError('Missing kernel build output: ' + str(path))
              mode = dict(line.split('=', 1) for line in marker.read_text().splitlines() if '=' in line)
              mode = {key.strip(): value.strip() for key, value in mode.items()}
              if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != str(int(self.output_symbols)):
                  raise RuntimeError('CSV diagnostics require DFRAME_EQUALIZER_OUTPUT_SYMBOLS=' + str(int(self.output_symbols)))
              if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts):
                  raise RuntimeError('Kernel build marker is stale; rebuild the kernel')
              self.estimator = mode.get('EQUALIZER_ALGORITHM', '')
              if not self.estimator:
                  raise RuntimeError('Kernel build marker is missing EQUALIZER_ALGORITHM')
              output = Path(self.output_path)
              output.parent.mkdir(parents=True, exist_ok=True)
              self.output_file = output.open('w', newline='', encoding='utf-8')
              self.writer = csv.writer(self.output_file)
              self.frame_index = 0
              self.writer.writerow([
                  'frame_index', 'estimator', 'frame_bytes', 'encoding', 'snr_db',
                  'bit_errors', 'bits_compared', 'ber', 'evm_rms_percent', 'evm_rms_db',
                  'evm_error_power', 'evm_reference_power',
              ])
              self.output_file.flush()
              return True

          @staticmethod
          def _metadata(metadata, key):
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              if pmt.is_uint64(value):
                  return int(pmt.to_uint64(value))
              if pmt.is_real(value):
                  return float(pmt.to_double(value))
              return ''

          def _handle_diag(self, message):
              if not pmt.is_pair(message):
                  return
              metadata, diagnostic = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(metadata) or not pmt.is_dict(diagnostic):
                  return
              bits = []
              for key in ('pre_viterbi', 'corrected_coded'):
                  value = pmt.dict_ref(diagnostic, pmt.intern(key), pmt.PMT_NIL)
                  if not pmt.is_u8vector(value):
                      return
                  bits.append(np.asarray(pmt.u8vector_elements(value), dtype=np.uint8))
              received, reference = bits
              if (not received.size or received.size != reference.size or
                      np.any(received > 1) or np.any(reference > 1)):
                  return
              errors = int(np.count_nonzero(received != reference))
              evm_percent = evm_db = error_power = reference_power = ''
              tx = pmt.dict_ref(diagnostic, pmt.intern('transmitted_iq'), pmt.PMT_NIL)
              eq = pmt.dict_ref(diagnostic, pmt.intern('equalized_iq'), pmt.PMT_NIL)
              if pmt.is_c32vector(tx) and pmt.is_c32vector(eq):
                  tx = np.asarray(pmt.c32vector_elements(tx), dtype=np.complex128)
                  eq = np.asarray(pmt.c32vector_elements(eq), dtype=np.complex128)
                  if (tx.size and tx.size % 48 == 0 and tx.size == eq.size and
                          np.all(np.isfinite(tx)) and np.all(np.isfinite(eq))):
                      power = float(np.vdot(tx, tx).real)
                      if power > 0:
                          reference_power = power
                          error_power = float(np.vdot(eq - tx, eq - tx).real)
                          ratio = float(np.sqrt(error_power / reference_power))
                          evm_percent = 100.0 * ratio
                          evm_db = float(20 * np.log10(ratio)) if ratio else float('-inf')
              with self.lock:
                  if self.output_file is None:
                      return
                  self.frame_index += 1
                  self.writer.writerow([
                      self.frame_index, self.estimator,
                      self._metadata(metadata, 'frame bytes'), self._metadata(metadata, 'encoding'),
                      self._metadata(metadata, 'snr'), errors, int(received.size),
                      errors / received.size, evm_percent, evm_db, error_power, reference_power,
                  ])
                  self.output_file.flush()

          def stop(self):
              with self.lock:
                  if self.output_file is not None:
                      self.output_file.close()
                      self.output_file = None
              return True
    build_dir: kernel_build_dir
    output_path: diagnostic_output
    output_symbols: 'True'
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_evm_0
  id: mlir_aie_mlir_aie_80211_phy_evm
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: kernel_build_dir+"/insts.bin"
    path_xclbin: kernel_build_dir+"/final.xclbin"
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, epy_snr_csv, diag]
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_evm_0, '0']
- [mlir_aie_mlir_aie_80211_phy_evm_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', mlir_aie_complex64_to_cint16_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
