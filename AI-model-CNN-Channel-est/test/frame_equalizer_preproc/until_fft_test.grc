options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: until_fft_test
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in base/test/until_fft.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/until_fft/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: dump_file
  id: variable
  parameters:
    value: dump_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_fft_test.py")).resolve().parent / "tmp_data" / "fft.iqdata")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: gain_BB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gain_IF
  id: variable
  parameters:
    value: '32'
  states: {}
- name: gain_RF
  id: variable
  parameters:
    value: '14'
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Pipeline kernel built by kernel/Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/until_fft/wifi_rx.py")).resolve().parent / "kernel" / "build")
  states: {}
- name: pcap_file
  id: variable
  parameters:
    value: pcap_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_fft_test.py")).resolve().parent / "tmp_data" / "until_fft.pcap")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: dump_file
    hdr_file: dump_file + ".hdr"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pcap_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"wifi_start"'
    type: complex
  states: {}
- name: dump_path
  id: parameter
  parameters:
    comment: FFT input for the native GNU Radio reference decoder.
    label: Dump path
    type: str
    value: ''
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: '2417000000.0'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: pcap_path
  id: parameter
  parameters:
    comment: Output PCAP path.
    label: PCAP path
    type: str
    value: ''
  states: {}

connections:
- [blocks_file_meta_source_0, '0', blocks_tag_gate_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_frame_equalizer_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_vector_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
