options:
  parameters:
    description: Per-frame SNR, pre-FEC coded BER and equalized-payload EVM on CRC-valid frames, excluding the final OFDM symbol.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: CPU SNR BER and EVM CSV
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    value: '"/home/piloteer/바탕화면/WiFi_Paper_Data/SUB/raw_capture/"'
  states: {}
- name: dataset
  id: variable
  parameters:
    value: '"206"'
  states: {}
- name: dataset
  id: variable
  parameters:
    value: '"stress_test_awgn_15db"'
  states: {state: disabled}
- name: dataset
  id: variable
  parameters:
    value: '"room_20260927"'
  states: {state: disabled}
- name: dataset
  id: variable
  parameters:
    value: '"stress_test"'
  states: {state: disabled}
- name: diagnostic_output
  id: variable
  parameters:
    value: '"data/tmp_out/ " + dataset + ".csv"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/" + dataset  + ".sigmf"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.412e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size+16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_iq_tag_sink
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, frequency_callback=lambda value: None):
              gr.sync_block.__init__(self, name='IQ Tag Frequency Retuner',
                                     in_sig=[np.complex64], out_sig=None)
              self.frequency_callback = frequency_callback
              self.frequency_key = pmt.intern('rx_freq')

          def work(self, input_items, output_items):
              count = len(input_items[0])
              for tag in self.get_tags_in_window(0, 0, count, self.frequency_key):
                  self.frequency_callback(pmt.to_double(tag.value))
              return count
    frequency_callback: 'lambda value: self.set_freq(value)'
  states: {}
- name: epy_snr_csv
  id: epy_block
  parameters:
    _source_code: |
      import csv
      import threading
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr


      class snr_csv(gr.basic_block):
          """One unbinned row per CRC-valid diagnostic PDU; no cross-frame joins."""

          def __init__(self, output_path='data/tmp_out/snr_ber_evm_cpu.csv',
                       estimator_label='LS'):
              gr.basic_block.__init__(self, name='SNR BER EVM CSV', in_sig=None, out_sig=None)
              self.output_path = output_path
              self.estimator_label = str(estimator_label)
              self.output_file = None
              self.writer = None
              self.frame_index = 0
              self.lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_diag)

          def start(self):
              output = Path(self.output_path)
              output.parent.mkdir(parents=True, exist_ok=True)
              self.output_file = output.open('w', newline='', encoding='utf-8')
              self.writer = csv.writer(self.output_file)
              self.frame_index = 0
              self.writer.writerow([
                  'frame_index', 'estimator', 'frame_bytes', 'encoding', 'snr_db',
                  'bit_errors', 'bits_compared', 'ber', 'evm_rms_percent', 'evm_rms_db',
                  'evm_error_power', 'evm_reference_power',
              ])
              self.output_file.flush()
              return True

          @staticmethod
          def _metadata(metadata, key):
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              if pmt.is_uint64(value):
                  return int(pmt.to_uint64(value))
              if pmt.is_real(value):
                  return float(pmt.to_double(value))
              return ''

          def _handle_diag(self, message):
              if not pmt.is_pair(message):
                  return
              metadata, diagnostic = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(metadata) or not pmt.is_dict(diagnostic):
                  return
              bits = []
              for key in ('pre_viterbi', 'corrected_coded'):
                  value = pmt.dict_ref(diagnostic, pmt.intern(key), pmt.PMT_NIL)
                  if not pmt.is_u8vector(value):
                      return
                  bits.append(np.asarray(pmt.u8vector_elements(value), dtype=np.uint8))
              received, reference = bits
              if (not received.size or received.size != reference.size or
                      np.any(received > 1) or np.any(reference > 1)):
                  return
              errors = int(np.count_nonzero(received != reference))
              evm_percent = evm_db = error_power = reference_power = ''
              tx = pmt.dict_ref(diagnostic, pmt.intern('transmitted_iq'), pmt.PMT_NIL)
              eq = pmt.dict_ref(diagnostic, pmt.intern('equalized_iq'), pmt.PMT_NIL)
              if pmt.is_c32vector(tx) and pmt.is_c32vector(eq):
                  tx = np.asarray(pmt.c32vector_elements(tx), dtype=np.complex128)
                  eq = np.asarray(pmt.c32vector_elements(eq), dtype=np.complex128)
                  if (tx.size and tx.size % 48 == 0 and tx.size == eq.size and
                          np.all(np.isfinite(tx)) and np.all(np.isfinite(eq))):
                      power = float(np.vdot(tx, tx).real)
                      if power > 0:
                          reference_power = power
                          error_power = float(np.vdot(eq - tx, eq - tx).real)
                          ratio = float(np.sqrt(error_power / reference_power))
                          evm_percent = 100.0 * ratio
                          evm_db = float(20 * np.log10(ratio)) if ratio else float('-inf')
              with self.lock:
                  if self.output_file is None:
                      return
                  self.frame_index += 1
                  self.writer.writerow([
                      self.frame_index, self.estimator_label,
                      self._metadata(metadata, 'frame bytes'), self._metadata(metadata, 'encoding'),
                      self._metadata(metadata, 'snr'), errors, int(received.size),
                      errors / received.size, evm_percent, evm_db, error_power, reference_power,
                  ])
                  self.output_file.flush()

          def stop(self):
              with self.lock:
                  if self.output_file is not None:
                      self.output_file.close()
                      self.output_file = None
              return True
    estimator_label: '"_"'
    output_path: diagnostic_output
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_debug_0
  id: ieee802_11_frame_equalizer_debug
  parameters:
    algo: ieee802_11.CNN_CHANNEL_MLP
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_debug_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, epy_snr_csv, diag]
- [ieee802_11_frame_equalizer_debug_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', blocks_complex_to_mag_squared_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', blocks_delay_0_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', blocks_multiply_xx_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', epy_block_iq_tag_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
