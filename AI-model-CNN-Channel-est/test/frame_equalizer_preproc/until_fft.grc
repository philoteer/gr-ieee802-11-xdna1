options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: fft_dump
    output_language: python
    run_options: run
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in base/test/frame_equalizer_preproc.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/fft_dump.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: dump_file
  id: variable
  parameters:
    comment: Scalarized complex64 FFT output with detached stream-tag metadata.
    value: dump_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/fft_dump.py")).resolve().parent / "tmp_data" / "fft.iqdata")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: input_path
  id: variable
  parameters:
    comment: Use the command-line dataset when supplied, otherwise the enabled file_path.
    value: dataset or file_path
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Pipeline kernel built by kernel/Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/fft_dump.py")).resolve().parent.parent / "until_fft" / "kernel" / "build")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_meta_sink_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: dump_file
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: dataset
  id: parameter
  parameters:
    comment: Optional SigMF prefix override, without the -data or -meta suffix.
    label: Dataset
    type: str
    value: ''
  states: {}
- name: dump_path
  id: parameter
  parameters:
    comment: Destination for scalarized complex64 FFT output and detached .hdr tags.
    label: Dump path
    type: str
    value: ''
  states: {}
- name: mlir_aie_cint32_to_complex64_0
  id: mlir_aie_cint32_to_complex64
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_tagged_int32_to_int64_0
  id: mlir_aie_mlir_aie_cpp_tagged_int32_to_int64
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    num_slots: '2'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: input_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [mlir_aie_cint32_to_complex64_0, '0', blocks_file_meta_sink_1, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_cpp_tagged_int32_to_int64_0, '0']
- [mlir_aie_mlir_aie_cpp_tagged_int32_to_int64_0, '0', mlir_aie_cint32_to_complex64_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
