options:
  parameters:
    category: Custom
    description: EVM and frame diagnostics from the AIE PHY receiver.
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: AIE EVM Diagnostics
  states: {}

blocks:
- name: diagnostic_label_init
  id: snippet
  parameters:
    code: self.set_diagnostic_estimator(self.diagnostic_estimator)
    section: main_after_init
  states: {}
- name: diagnostic_estimator
  id: variable
  parameters:
    comment: Loaded from kernel/build/frame_equalizer_build_mode.txt before block construction.
    value: None
  states: {}
- name: diagnostic_evm_output
  id: variable
  parameters:
    comment: Bounded EVM measurement export.
    value: '"data/tmp_out/evm_measurement.jsonl"'
  states: {}
- name: diagnostic_max_records
  id: variable
  parameters:
    comment: Maximum number of frame and CRC event records written to JSONL.
    value: '10000'
  states: {}
- name: diagnostic_output
  id: variable
  parameters:
    comment: Bounded receiver-frame diagnostic export.
    value: '"data/tmp_out/frame_diagnostic-evm_mode.jsonl"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"data/raw_capture/206.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/tmp_out/replaced.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_evm_diagnostic
  id: epy_block
  parameters:
    _source_code: |-
      import json
      import os
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      class evm_diagnostic(gr.basic_block):
          def __init__(self, output_path='data/tmp_out/evm_measurement.jsonl',
                       max_records=10000, report_interval=25, estimator_label='LS'):
              gr.basic_block.__init__(
                  self,
                  name='evm_diagnostic',
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.output_file = None
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.record_count = 0
              self.evm_samples = 0
              self.error_power_sum = 0.0
              self.reference_power_sum = 0.0
              self.aligned_evm_sum = 0.0
              self.output_lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_iq_data)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              if output_path:
                  self.output_file = open(output_path, 'w', encoding='ascii')

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              if len(input_items[0]):
                  self.consume(0, len(input_items[0]))
              return 0

          def _write_record(self, record):
              with self.output_lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(
                      json.dumps(record, separators=(',', ':'), allow_nan=False) + '\n'
                  )
                  self.output_file.flush()
                  self.record_count += 1

          @staticmethod
          def _metadata_uint64(metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _handle_iq_data(self, message):
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'expected_metadata_and_iq_dictionary',
                  })
                  return

              metadata = pmt.car(message)
              iq_data = pmt.cdr(message)
              vectors = {}
              for key in ('transmitted_iq', 'equalized_iq'):
                  value = pmt.dict_ref(iq_data, pmt.intern(key), pmt.PMT_NIL)
                  if not pmt.is_c32vector(value):
                      self._write_record({
                          'event': 'invalid_evm_message',
                          'reason': 'missing_complex_vector',
                          'vector': key,
                      })
                      return
                  vectors[key] = np.asarray(
                      pmt.c32vector_elements(value), dtype=np.complex128
                  )

              transmitted = vectors['transmitted_iq']
              equalized = vectors['equalized_iq']
              if (transmitted.size == 0 or transmitted.size % 48 != 0 or
                            equalized.size != transmitted.size or
                      not np.all(np.isfinite(transmitted)) or
                      not np.all(np.isfinite(equalized))):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'invalid_vector_size_or_nonfinite_values',
                      'transmitted_iq_size': int(transmitted.size),
                      'received_iq_size': None,
                      'equalized_iq_size': int(equalized.size),
                  })
                  return

              reference_power = float(np.vdot(transmitted, transmitted).real)
              if reference_power <= np.finfo(np.float64).tiny:
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'zero_reference_power',
                  })
                  return

              error = equalized - transmitted
              error_power = float(np.vdot(error, error).real)
              evm_ratio = float(np.sqrt(error_power / reference_power))
              gain = np.vdot(transmitted, equalized) / reference_power
              aligned_error = equalized / gain - transmitted if abs(gain) else error
              aligned_evm_ratio = float(np.sqrt(
                  np.vdot(aligned_error, aligned_error).real / reference_power
              ))
              evm_percent = 100.0 * evm_ratio
              aligned_evm_percent = 100.0 * aligned_evm_ratio
              evm_db = float(20.0 * np.log10(max(evm_ratio, 1e-15)))
              frame_bytes = self._metadata_uint64(metadata, 'frame bytes')
              encoding = self._metadata_uint64(metadata, 'encoding')

              self.evm_samples += 1
              self.error_power_sum += error_power
              self.reference_power_sum += reference_power
              self.aligned_evm_sum += aligned_evm_percent
              cumulative_evm_percent = float(100.0 * np.sqrt(
                  self.error_power_sum / self.reference_power_sum
              ))
              mean_aligned_evm_percent = self.aligned_evm_sum / self.evm_samples
              self._write_record({
                  'event': 'evm',
                  'sample_index': self.evm_samples,
                  'frame_bytes': frame_bytes,
                  'encoding': encoding,
                  'payload_symbols_compared': int(transmitted.size // 48),
                  'complex_symbols_compared': int(transmitted.size),
                  'evm_rms_percent': evm_percent,
                  'evm_rms_db': evm_db,
                  'mer_db': -evm_db,
                  'gain_magnitude_db': 20.0 * np.log10(max(abs(gain), 1e-15)),
                  'gain_phase_deg': float(np.degrees(np.angle(gain))),
                  'gain_aligned_evm_rms_percent': aligned_evm_percent,
                  'cumulative_evm_rms_percent': cumulative_evm_percent,
                  'mean_gain_aligned_evm_percent': mean_aligned_evm_percent,
                  'region': 'CRC-valid equalized payload symbols, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              if self.evm_samples == 1 or self.evm_samples % self.report_interval == 0:
                  print(
                      'EVM: sample={} encoding={} symbols={} raw={:.4f}% aligned={:.4f}% cumulative={:.4f}%'.format(
                          self.evm_samples, encoding, transmitted.size // 48,
                          evm_percent, aligned_evm_percent, cumulative_evm_percent
                      )
                  )

          def stop(self):
              if self.output_file is not None:
                  self.output_file.close()
                  self.output_file = None
              return True
    estimator_label: diagnostic_estimator
    max_records: diagnostic_max_records
    output_path: diagnostic_evm_output
    report_interval: '25'
  states: {}
- name: epy_frame_diagnostic
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class frame_diagnostic(gr.basic_block):
          def __init__(self, output_path='data/tmp_out/frame_diagnostic.jsonl',
                       max_records=10000, report_interval=25,
                       headless_idle_seconds=10.0, estimator_label='LS'):
              gr.basic_block.__init__(
                  self,
                  name='frame_diagnostic',
                  in_sig=[np.int8],
                  out_sig=[np.float32, np.float32, np.float32],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.record_count = 0
              self.crc_valid_count = 0
              self.pre_fec_bit_errors = 0
              self.pre_fec_bits_compared = 0
              self.pre_fec_ber_samples = 0
              self.latest_ber = 0.0
              self.cumulative_ber = 0.0
              self.pending = []
              self.lock = threading.Lock()
              self.last_work = time.monotonic()
              self.seen_input = False
              self.stopping = False
              self.message_port_register_in(pmt.intern('crc_ok'))
              self.set_msg_handler(pmt.intern('crc_ok'), self._handle_crc_ok)
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_diag)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              self.output_file = open(output_path, 'w', encoding='ascii') if output_path else None

              if os.environ.get('WIFI_DIAGNOSTIC_HEADLESS') == '1':
                  self.headless_thread = threading.Thread(
                      target=self._headless_watchdog,
                      args=(max(1.0, float(headless_idle_seconds)),),
                      daemon=True,
                  )
                  self.headless_thread.start()

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              if len(input_items[0]):
                  self.seen_input = True
                  self.last_work = time.monotonic()
                  self.consume(0, len(input_items[0]))
              with self.lock:
                  produced = min(len(self.pending), *(len(items) for items in output_items))
                  for index in range(produced):
                      values = self.pending.pop(0)
                      for port, value in enumerate(values):
                          output_items[port][index] = value
              return produced

          def _write_record(self, record):
              with self.lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(
                      json.dumps(record, separators=(',', ':'), allow_nan=False) + '\n'
                  )
                  self.output_file.flush()
                  self.record_count += 1

          def _queue_metrics(self):
              with self.lock:
                  self.pending.append((
                      float(self.crc_valid_count),
                      self.latest_ber,
                      self.cumulative_ber,
                  ))

          def _handle_crc_ok(self, _message):
              with self.lock:
                  self.crc_valid_count += 1
                  crc_valid_count = self.crc_valid_count
              self._write_record({
                  'event': 'crc_ok',
                  'crc_valid_count': crc_valid_count,
                  'estimator': self.estimator_label,
              })
              self._queue_metrics()

          @staticmethod
          def _metadata_uint64(metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _handle_diag(self, message):
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  return
              metadata = pmt.car(message)
              diagnostic = pmt.cdr(message)
              received = pmt.dict_ref(diagnostic, pmt.intern('pre_viterbi'), pmt.PMT_NIL)
              corrected = pmt.dict_ref(diagnostic, pmt.intern('corrected_coded'), pmt.PMT_NIL)
              if not pmt.is_u8vector(received) or not pmt.is_u8vector(corrected):
                  return
              rx_bits = np.asarray(pmt.u8vector_elements(received), dtype=np.uint8)
              reference_bits = np.asarray(pmt.u8vector_elements(corrected), dtype=np.uint8)
              if (rx_bits.size == 0 or rx_bits.size != reference_bits.size or
                      np.any(rx_bits > 1) or np.any(reference_bits > 1)):
                  return

              bit_errors = int(np.count_nonzero(rx_bits != reference_bits))
              bits_compared = int(rx_bits.size)
              sample_ber = bit_errors / bits_compared
              with self.lock:
                  self.pre_fec_ber_samples += 1
                  self.pre_fec_bit_errors += bit_errors
                  self.pre_fec_bits_compared += bits_compared
                  self.latest_ber = sample_ber
                  self.cumulative_ber = self.pre_fec_bit_errors / self.pre_fec_bits_compared
                  sample_index = self.pre_fec_ber_samples
                  cumulative_ber = self.cumulative_ber
              self._write_record({
                  'event': 'pre_fec_coded_ber',
                  'sample_index': sample_index,
                  'frame_bytes': self._metadata_uint64(metadata, 'frame bytes'),
                  'encoding': self._metadata_uint64(metadata, 'encoding'),
                  'bit_errors': bit_errors,
                  'bits_compared': bits_compared,
                  'ber': sample_ber,
                  'cumulative_bit_errors': self.pre_fec_bit_errors,
                  'cumulative_bits_compared': self.pre_fec_bits_compared,
                  'cumulative_ber': cumulative_ber,
                  'region': 'deinterleaved coded bits, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              self._queue_metrics()
              if sample_index == 1 or sample_index % self.report_interval == 0:
                  print('pre-FEC coded BER sample {}: {}/{} ({:.6g}); cumulative {:.6g}'.format(
                      sample_index, bit_errors, bits_compared, sample_ber, cumulative_ber
                  ))

          def _headless_watchdog(self, idle_seconds):
              while not self.stopping:
                  time.sleep(0.25)
                  if self.seen_input and time.monotonic() - self.last_work >= idle_seconds:
                      try:
                          from PyQt5 import QtWidgets
                          app = QtWidgets.QApplication.instance()
                          if app is not None:
                              app.quit()
                      except ImportError:
                          pass
                      return

          def stop(self):
              self.stopping = True
              if self.output_file is not None:
                  self.output_file.close()
                  self.output_file = None
              return True
    estimator_label: diagnostic_estimator
    headless_idle_seconds: '10.0'
    max_records: diagnostic_max_records
    output_path: diagnostic_output
    report_interval: '25'
  states: {}
- name: evm_build_mode_check
  id: snippet
  parameters:
    code: |-
      from pathlib import Path

      build = Path('kernel/build')
      marker = build / 'frame_equalizer_build_mode.txt'
      artifacts = [build / 'final.xclbin', build / 'insts.bin']
      missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
      if missing: raise RuntimeError('EVM diagnostics require kernel build output(s): ' + ', '.join(missing) + '; run `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile` from stage42/')
      mode = dict((parts[0].strip(), parts[1].strip()) for parts in (line.split('=', 1) for line in marker.read_text(encoding='ascii').splitlines()) if len(parts) == 2)
      if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '1': raise RuntimeError('EVM diagnostics require DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1; rebuild with `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile`')
      if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts): raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild the kernel')
      if not mode.get('EQUALIZER_ALGORITHM'): raise RuntimeError(str(marker) + ' is missing EQUALIZER_ALGORITHM; rebuild the kernel')
      self.diagnostic_estimator = mode['EQUALIZER_ALGORITHM']
    section: init_before_blocks
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_evm_0
  id: mlir_aie_mlir_aie_80211_phy_evm
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: qtgui_number_sink_frame_metrics
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.0'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,2
    label1: '"CRC-valid frames"'
    label2: '"Pre-FEC coded BER"'
    label3: '"Cumulative coded BER"'
    min: '0'
    name: '"Frame Metrics"'
    nconnections: '3'
    type: float
    unit1: '"frames"'
    unit2: '""'
    unit3: '""'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: diag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: diag
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [epy_frame_diagnostic, '0', qtgui_number_sink_frame_metrics, '0']
- [epy_frame_diagnostic, '1', qtgui_number_sink_frame_metrics, '1']
- [epy_frame_diagnostic, '2', qtgui_number_sink_frame_metrics, '2']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, virtual_sink_1_0_0, '0']
- [ieee802_11_decode_mac_EVM_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_EVM_0, out, virtual_sink_1_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_evm_0, '0']
- [mlir_aie_mlir_aie_80211_phy_evm_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_mlir_aie_80211_phy_evm_0, '0', virtual_sink_1, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_1, '0', epy_evm_diagnostic, '0']
- [virtual_source_1, '0', epy_frame_diagnostic, '0']
- [virtual_source_1_0, '0', epy_frame_diagnostic, crc_ok]
- [virtual_source_1_0_0, '0', epy_evm_diagnostic, diag]
- [virtual_source_1_0_0, '0', epy_frame_diagnostic, diag]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
