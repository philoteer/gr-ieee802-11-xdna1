options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: until_preproc_test
    output_language: python
    run_options: run
    title: Post-preprocess Receive Test
  states: {}

blocks:
- name: estimator
  id: parameter
  parameters:
    label: Estimator (cnn or mlp)
    type: str
    value: cnn
  states: {}
- name: estimator_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(globals().get('__file__', 'AI-model-CNN-Channel-est/test/frame_equalizer_preproc/until_preproc_test.py')).resolve().parent / 'channel_est' / 'build' / estimator)
  states: {}
- name: to_fixed
  id: mlir_aie_complex64_to_cint32
  parameters:
    integer_bits: '16'
    fractional_bits: '15'
    safe: 'False'
  states: {}
- name: channel_estimate
  id: mlir_aie_mlir_aie_cpp_tagged_int64_to_int64
  parameters:
    path_xclbin: estimator_dir + "/final.xclbin"
    path_insts_bin: estimator_dir + "/insts.bin"
    kernel_name: MLIR_AIE
    VECTOR_SIZE: '16384'
    N_TILES: '16'
    num_slots: '1'
    preprocess: 'False'
    channel_estimate: 'True'
  states: {}
- name: to_complex
  id: mlir_aie_cint32_to_complex64
  parameters:
    integer_bits: '16'
    fractional_bits: '15'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in base/test/frame_equalizer_preproc.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_preproc_test.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: dump_file
  id: variable
  parameters:
    value: dump_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_preproc_test.py")).resolve().parent / "tmp_data" / "preproc.iqdata")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Standalone equalize kernel built by equalize/Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_preproc_test.py")).resolve().parent / "equalize" / "build")
  states: {}
- name: pcap_file
  id: variable
  parameters:
    value: pcap_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_preproc_test.py")).resolve().parent / "tmp_data" / "until_preproc.pcap")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: dump_file
    hdr_file: dump_file + ".hdr"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pcap_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"wifi_start"'
    type: complex
  states: {}
- name: dump_path
  id: parameter
  parameters:
    comment: Prepared samples and tags from preprocess_dump; run the remaining receive chain.
    label: Dump path
    type: str
    value: ''
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: 2.412e9
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_equalizer_test_0
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
    prepared_input: 'False'
    estimated_input: 'True'
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain_BB
    bw0: samp_rate
    freq0: freq
    gain0: gain_RF
    gain_mode0: 'False'
    if_gain0: gain_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pcap_path
  id: parameter
  parameters:
    comment: Output PCAP path.
    label: PCAP path
    type: str
    value: ''
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {state: disabled}

connections:
- [blocks_file_meta_source_0, '0', blocks_tag_gate_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [blocks_tag_gate_0, '0', to_fixed, '0']
- [to_fixed, '0', channel_estimate, '0']
- [channel_estimate, '0', to_complex, '0']
- [to_complex, '0', mlir_aie_mlir_aie_cpp_equalizer_test_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [mlir_aie_mlir_aie_cpp_equalizer_test_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
