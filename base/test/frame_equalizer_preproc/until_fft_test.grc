options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: until_fft_test
    output_language: python
    run_options: run
  states: {}

blocks:
- name: dump_path
  id: parameter
  parameters:
    comment: FFT input for the native GNU Radio reference decoder.
    label: Dump path
    type: str
    value: ''
  states: {}
- name: pcap_path
  id: parameter
  parameters:
    comment: Output PCAP path.
    label: PCAP path
    type: str
    value: ''
  states: {}
- name: dump_file
  id: variable
  parameters:
    value: dump_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_fft_test.py")).resolve().parent / "tmp_data" / "fft.iqdata")
  states: {}
- name: pcap_file
  id: variable
  parameters:
    value: pcap_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/until_fft_test.py")).resolve().parent / "tmp_data" / "until_fft.pcap")
  states: {}
- name: chan_est
  id: variable
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in base/test/until_fft.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/until_fft/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: freq
  id: parameter
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    orient: Qt.QVBoxLayout
    type: eng_float
    value: '2417000000.0'
    widget: combo_box
  states: {}
- name: gain_BB
  id: variable
  parameters:
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
    widget: counter_slider
  states: {}
- name: gain_IF
  id: variable
  parameters:
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
    widget: counter_slider
  states: {}
- name: gain_RF
  id: variable
  parameters:
    min_len: '200'
    orient: QtCore.Qt.Horizontal
    rangeType: float
    start: '0'
    step: '14'
    stop: '14'
    value: '14'
    widget: counter_slider
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Pipeline kernel built by kernel/Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/until_fft/wifi_rx.py")).resolve().parent / "kernel" / "build")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: data_dir + "/tmp_out/until_fft_replaced.iqdata"
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: dump_file
    hdr_file: dump_file + ".hdr"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pcap_file
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"wifi_start"'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: "#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n#\n# Copyright 2026 gr-mlir_aie author.\n#\n# SPDX-License-Identifier: GPL-3.0-or-later\n#\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfrom aie.dialects.aie import *\nfrom aie.extras.context import mlir_mod_ctx\nfrom aie.iron import Program, Runtime, Worker, ObjectFifo\nfrom aie.iron.placers import SequentialPlacer\nfrom aie.iron.controlflow import range_\n\nimport aie.iron as iron\nfrom aie.utils import NPUKernel, DefaultNPURuntime, get_current_device\n\nDEV = iron.get_current_device()\nDTYPE_IN=np.int32\nDTYPE_OUT=np.int32\n\nclass mlir_aie_python_int32(gr.basic_block):\n    \"\"\"\n    docstring for block mlir_aie_python_int32\n    \"\"\"\n    def __init__(self, path_xclbin=\"kernel/build/final.xclbin\",path_insts_bin=\"kernel/build/insts.bin\", VECTOR_SIZE = 4096):\n        gr.basic_block.__init__(self,\n            name=\"mlir_aie_python_int32\",\n            in_sig=[DTYPE_IN, ],\n            out_sig=[DTYPE_OUT, ])\n            \n        npu_kernel = NPUKernel(\n            path_xclbin,\n            path_insts_bin,\n            kernel_name=\"MLIR_AIE\",\n        )\n         \n        self.set_tag_propagation_policy(gr.TPP_DONT)\n        self.kernel_handle = DefaultNPURuntime.load(npu_kernel)\n        self.out_buf = iron.zeros(VECTOR_SIZE, dtype=DTYPE_OUT)\n        self.MAX_TAGS_PER_TILE = 7\n        self.METADATA_WORDS_PER_TILE = 2 + 2 * self.MAX_TAGS_PER_TILE\n        self.out_meta_buf = iron.zeros(4 * self.METADATA_WORDS_PER_TILE, dtype=np.int32)\n        self.VECTOR_SIZE = VECTOR_SIZE\n        self.TILE_SIZE = VECTOR_SIZE // 4\n        self.tag_key = pmt.intern(\"wifi_start\")\n        self.tag_srcid = pmt.intern(\"sync_short\")\n\n    #TODO implement forecast()\n    def forecast(self, noutput_items, ninputs):\n        #ninput_items_required = [min(self.VECTOR_SIZE, noutput_items)] * ninputs\n        ninput_items_required = [noutput_items] * ninputs   \n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        n_input_items = len(in0)\n        n_output_items = len(out0)\n        \n        n_chunks = min(n_input_items // self.VECTOR_SIZE, n_output_items // self.VECTOR_SIZE)\n\n        if n_chunks == 0:\n            return 0\n\n        total_produced = 0\n        for i in range(n_chunks):\n            start_idx = i * self.VECTOR_SIZE\n            end_idx = start_idx + self.VECTOR_SIZE\n            \n            current_in_tensor = iron.tensor(in0[start_idx:end_idx], dtype=DTYPE_IN)\n            buffers = [current_in_tensor, self.out_buf, self.out_meta_buf]\n            DefaultNPURuntime.run(self.kernel_handle, buffers)\n\n            out_np = self.out_buf.numpy()\n            out_meta = self.out_meta_buf.numpy().reshape(4, self.METADATA_WORDS_PER_TILE)\n            output_abs_start = self.nitems_written(0)\n            for tile_idx, tile_meta in enumerate(out_meta):\n                tile_len = int(tile_meta[0])\n                tag_count = min(int(tile_meta[1]), self.MAX_TAGS_PER_TILE)\n                tile_start = tile_idx * self.TILE_SIZE\n                tile_end = tile_start + tile_len\n                next_total_produced = total_produced + tile_len\n                out0[total_produced:next_total_produced] = out_np[tile_start:tile_end]\n\n                tile_abs_start = output_abs_start + total_produced\n                for tag_idx in range(tag_count):\n                    tag_offset = int(tile_meta[2 + 2 * tag_idx])\n                    tag_bits = np.uint32(int(tile_meta[3 + 2 * tag_idx]) & 0xffffffff)\n                    tag_value = float(np.array([tag_bits], dtype=np.uint32).view(np.float32)[0])\n                    if 0 <= tag_offset < tile_len:\n                        self.add_item_tag(\n                            0,\n                            tile_abs_start + tag_offset,\n                            self.tag_key,\n                            pmt.from_double(tag_value),\n                            self.tag_srcid,\n                        )\n\n                total_produced = next_total_produced\n        \n        total_processed = n_chunks * self.VECTOR_SIZE\n        self.consume_each(total_processed)\n        \n        return total_produced\n\n"
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain_BB
    bw0: samp_rate
    freq0: freq
    gain0: gain_RF
    gain_mode0: 'False'
    if_gain0: gain_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_meta_source_0, '0', blocks_tag_gate_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_frame_equalizer_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_char_to_float_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
