options:
  parameters:
    category: Custom
    description: Benchmark only frame_equalizer_preprocess on recorded FFT output.
    generate_options: no_gui
    id: preprocess_speedtest
    output_language: python
    run_options: run
    title: Frame Equalizer Preprocess Speed Test
  states: {}

blocks:
- name: dump_file
  id: variable
  parameters:
    value: dump_path or str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/preprocess_speedtest.py")).resolve().parent / "tmp_data" / "fft.iqdata")
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Standalone frame-equalizer kernel built by the local Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/frame_equalizer_preproc/preprocess_speedtest.py")).resolve().parent / "preprocess" / "build")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: VECTOR_SIZE uses fixed 1024-sample AIE tiles.
    value: '16384'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    comment: Recorded, scalarized complex output of the FFT block
    detached: 'True'
    file: dump_file
    hdr_file: dump_file + ".hdr"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: dump_path
  id: parameter
  parameters:
    comment: Complex64 FFT output from dump.grc, with detached .hdr metadata.
    label: Dump path
    type: str
    value: ''
  states: {}
- name: freq
  id: parameter
  parameters:
    comment: Nominal center frequency from the dataset's SigMF capture metadata.
    label: Frequency
    type: eng_float
    value: 2.417e9
  states: {}
- name: mlir_aie_cint32_to_complex64_0_0
  id: mlir_aie_cint32_to_complex64
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
  states: {}
- name: mlir_aie_complex64_to_cint32_0
  id: mlir_aie_complex64_to_cint32
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_tagged_int64_to_int64_0
  id: mlir_aie_mlir_aie_cpp_tagged_int64_to_int64
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
    preprocess: 'True'
  states: {}

connections:
- [blocks_file_meta_source_0, '0', blocks_probe_rate_0, '0']
- [blocks_file_meta_source_0, '0', mlir_aie_complex64_to_cint32_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [mlir_aie_cint32_to_complex64_0_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_complex64_to_cint32_0, '0', mlir_aie_mlir_aie_cpp_tagged_int64_to_int64_0, '0']
- [mlir_aie_mlir_aie_cpp_tagged_int64_to_int64_0, '0', mlir_aie_cint32_to_complex64_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
